SRC_URI = "git://codeaurora.org/quic/filesystems/fs/external/mtd-utils;protocol=git;tag=995cfe51b0a3cf32f381c140bf72b21bf91cef1b \
           file://add-exclusion-to-mkfs-jffs2-git-2.patch"
PR = "r1"
