FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://Remove-MLS-constraints.patch"
