# Set machine specific options
include ${MACHINE}-hf-image.inc

# Build the image
require mdm-image.bb
