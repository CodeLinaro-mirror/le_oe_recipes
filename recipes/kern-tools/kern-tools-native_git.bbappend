PR = "r13"

SRC_URI = "${CLO_LE_GIT}/platform/external/yocto-kernel-tools;protocol=https"
