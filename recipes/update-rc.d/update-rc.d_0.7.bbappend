SRC_URI = "${CLO_LE_GIT}/platform/external/update-rc.d;protocol=https \
           file://add-verbose.patch \
           file://check-if-symlinks-are-valid.patch \
          "

PR = "r6"
