SRC_URI = "${CLO_LE_GIT}/gnome/gtk-doc-stub.git;protocol=https"
