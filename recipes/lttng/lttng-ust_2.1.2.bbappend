SRC_URI = "${CLO_LE_GIT}/platform/external/lttng-ust;protocol=https \
           file://depends-liblttng-ust-tracepoin.patch \
           "

PR = "r1"
