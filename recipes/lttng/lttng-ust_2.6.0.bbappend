SRC_URI = "${CLO_LE_GIT}/platform/external/lttng-ust;protocol=https;branch=caf_migration/lttng/stable-2.6 \
           "

PR = "r2"
