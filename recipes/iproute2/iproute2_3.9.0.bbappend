SRC_URI = "git://codeaurora.org/quic/le/platform/external/iproute2;protocol=git \
           file://configure-cross.patch"

PR = "r1"
