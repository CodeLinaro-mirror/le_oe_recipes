EXTRA_OECONF_class-native += "--disable-werror"
