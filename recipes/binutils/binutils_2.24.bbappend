FILESEXTRAPATHS := "${THISDIR}/files"
SRC_URI += "\
    file://Resolve-binutils-build-error.patch \
"
