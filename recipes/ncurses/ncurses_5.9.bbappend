FILESEXTRAPATHS := "${THISDIR}/files"
SRC_URI += "\
    file://Resolve-ncurses-build-error.patch \
"
